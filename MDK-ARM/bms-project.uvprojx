# Keil uVision project bms-project.uvprojx, settings and files
target bms-project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B1CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: bms-project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;./source/App;./source/Com;./source/Int;./thirdpart/FreeRTOS/include;./source/Int/OLED;./source/Int/BQ76952;./source/Int/SC8815;.\source\Int\CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c i2c.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_fdcan.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group App
    ./source/App/: App_Main.c App_Main.h App_Battery_Control.c App_Battery_Control.h App_Battery_Manager.c App_Battery_Manager.h
  group Com
    ./source/Com/: Com_BatteryParam.c Com_BatteryParam.h Com_SOC.c Com_SOC.h
  group Int
    ./source/Int/OLED/: Int_Display.c Int_Display.h Int_font.h Int_OLED.c Int_OLED.h
    ./source/Int/BQ76952/: Int_BQ76952.c Int_BQ76952.h Int_BQ76952_BSP.h
    ./source/Int/SC8815/: Int_SC8815.c Int_SC8815.h Int_SC8815_BSP.h
    ./source/Int/CAN/: Int_CAN.c Int_CAN.h
  group thirdpart/FreeRTOS
    ./thirdpart/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./thirdpart/FreeRTOS/portable/: heap_4.c port.c
    ./thirdpart/FreeRTOS/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0
